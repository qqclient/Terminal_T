# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GTW_IAP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\USER;.\FWlib\inc;.\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c usart.c Stm32Flash.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
