# Keil uVision project Terminal.uvproj, settings and files
target Terminal (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GTW +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Base;.\USER;.\nmea_decode;.\FWLib\CMSIS;.\FWlib\inc;.\uCOS-III\uC-CPU;.\uCOS-III\uC-LIB;.\uCOS-III\uCOS-III;.\USBUser;.\USBLib;.\MPU6050;.\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Base
    ./Base/: hw_init.c Protocol.c Queue.c GTW_EleDriver.c GTW_PoliceApp.c GTW_ServerApp.c GTW_UserApp.c GTW_LightApp.c GTW_SetupApp.c GTW_DataCollector.c GTW_Illegal.c
  group USER
    ./USER/: decoding_carno.c smartcard_user.c Stm32Flash.c
    ./user/: debug.c ElecDriverLic.c flash_user.c radio_user.c wifibt_user.c main.c gps_user.c
  group DEVICE
    ./user/: calendar.c flash_driver.c gprs_gsm_driver.c io_detection.c radio_driver.c stm32f10x_it.c utility.c
    ./USER/: gps_driver.c speech.c smartcard.c
  group MPU6050
    ./MPU6050/: mpu6050.c mpuiic.c
    ./MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./FWLib/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./FWLib/startup/: startup_stm32f10x_hd.s
  group uCOS-III/CPU
    ./uCOS-III/uC-CPU/: cpu_c.c cpu_core.c cpu_a.s
  group uCOS-III/LIB
    ./uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uCOS-III/Source
    ./uCOS-III/uCOS-III/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.s
  group USBLib
    ./USBLib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USBUser
    ./USBUser/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_main.c
